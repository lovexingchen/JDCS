# Keil uVision project CS-GY.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: CS-GY +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./systick/: systick.c
    ./USART/: USART.c
    ./AD/: ADzh.c
    ./DHT11/: DHT11.C
    ./BH1750/: BH1750.c
